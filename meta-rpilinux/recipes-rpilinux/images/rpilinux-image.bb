require recipes-core/images/core-image-base.bb
